// TriggerCANoe.cpp : Sample application to trigger a global event
// The name of the events must match the ones created in the C-Library

#include <windows.h>
#include <stdio.h>

void print_help()
{
  printf("Invalid/missing parameter.\n\nUsage:\n\n");
  printf("TriggerCANoe.exe time    - increment simulation time\n");
  printf("TriggerCANoe.exe message - generate message\n");
}

int main(int argc, char *argv[])
{
  if (argc != 2)
  {
    print_help();
    return 0;
  }

  if (strcmp(argv[1], "time") == 0)
  {
    HANDLE hEvent = OpenEventA(EVENT_MODIFY_STATE, false, "Global\\CANoeSignalTriggerTimeDemo");
    SetEvent(hEvent);
  }
  else if (strcmp(argv[1], "message") == 0)
  {
    HANDLE hEvent = OpenEventA(EVENT_MODIFY_STATE, false, "Global\\CANoeSignalTriggerMessageDemo");
    SetEvent(hEvent);
  }
  else
  {
    print_help();
  }
  return 0;
}

